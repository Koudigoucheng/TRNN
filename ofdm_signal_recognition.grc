<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ofdm_signal_recognition</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Transmit a pre-defined signal (a complex sine) as OFDM packets.</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>OFDM Signal Recognition</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>StartGenerateDataset</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>5,4,1,1</value></param>
<param><key>label</key><value>StartGenerateDataset</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>doppler_freq</value></param>
<param><key>value</key><value>2</value></param>
<param><key>gui_hint</key><value>5,2,1,1</value></param>
<param><key>label</key><value>Doppler_Freq</value></param>
<param><key>min_len</key><value>20</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>100</value></param>
<param><key>stop</key><value>500</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>expected_snr</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>5,3,1,1</value></param>
<param><key>label</key><value>expected_SNR</value></param>
<param><key>min_len</key><value>20</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-10</value></param>
<param><key>step</key><value>2</value></param>
<param><key>stop</key><value>20</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>5,1,1,1</value></param>
<param><key>label</key><value>Frequency Offset (Multiples of Sub-carrier spacing)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-3</value></param>
<param><key>step</key><value>.01</value></param>
<param><key>stop</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_key</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise_voltage</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>occupied_carriers</value></param>
<param><key>value</key><value>(range(-26, -21) + range(-20, -7) + range(-6, 0) + range(1, 7) + range(8, 21) + range(22, 27),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_carriers</value></param>
<param><key>value</key><value>((-21, -7, 7, 21,),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_symbols</value></param>
<param><key>value</key><value>((1, 1, 1, -1,),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word1</value></param>
<param><key>value</key><value>[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word2</value></param>
<param><key>value</key><value>[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] </value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>BlindRecognition</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import h5py
import tensorflow as tf
from keras.models import load_model
import os
import datetime

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, 
		modulations_list=['BPSK', 'QPSK', '8PSK'],
		rec_data_length=1024,  # Data length for identification
		model_file='/home/lin/workarea/PycharmProjects/gnuradio/mpsk/Blind_Mod_Rec_ResNet.h5',
		work_mode=True,  # if true,recognize
		true_label='QPSK'
		):  # only default arguments here

        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Blind Recognition',   # will show up in GRC
            in_sig=[np.complex64],
            out_sig=[np.int8]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
	self.modulations=modulations_list
	self.rec_data_length=rec_data_length
	self.received_data = []
	self.received_data_length = 0
	self.model_file=model_file
	self.work_mode=work_mode
	self.true_label=true_label
	self.predict_cnt=0
	self.predict_correct_cnt=0
	self.predict_correct_index=self.modulations.index(self.true_label)
	print('self.predict_correct_index',self.predict_correct_index)
	self.predict_accuracy=0
	


	print 'Blind Recognition Work Mode:', self.work_mode   
	# Prevent GPU memory overflow
	if self.work_mode:
		os.environ["CUDA_DEVICE_ORDER"] = "PCI_BUS_ID"
		os.environ['CUDA_VISIBLE_DEVICES'] = "0"  # select gpu,use cpu if -1
		self.config = tf.compat.v1.ConfigProto(allow_soft_placement=True)
		self.config.allow_soft_placement = True
		self.config.gpu_options.per_process_gpu_memory_fraction = 0.8
		self.config.gpu_options.allow_growth = True
		sess = tf.compat.v1.Session(config=self.config)
		print 'loading model from file:', self.model_file
		print("Load Start:",datetime.datetime.now())
		self.model =load_model(self.model_file,compile=False)
		print("Load End:",datetime.datetime.now())

		predict_data = np.zeros((1, 1024, 2), dtype=np.int)
		self.predict_starttime = datetime.datetime.now()
		print("Predict Start:",self.predict_starttime)
		predict = self.model.predict(predict_data)
		self.predict_endtime = datetime.datetime.now()
		predict_list = list(np.squeeze(predict))
		predict = predict_list.index(max(predict_list))
		print('Recognize as:', predict)
		print("Predict End:",self.predict_endtime - self.predict_starttime)

	
    def work(self, input_items, output_items):
        """example: multiply with constant"""
	temp_array = input_items[0][:]
	temp_data_length = len(list(temp_array))
	self.received_data_length = self.received_data_length + temp_data_length
	if not len(self.received_data):  # if self.received_data is null
		self.received_data = temp_array
	else:
		self.received_data = np.concatenate((self.received_data, temp_array), axis=0)
	#print 'received_data_len:', self.received_data_length, 'temp_array.shape:', temp_array.shape, 'self.received_data.shape:', self.received_data.shape
	if self.work_mode:
		if self.received_data_length - self.rec_data_length &gt; 0:
			self.received_data = self.received_data[0:self.rec_data_length]  # (None,) --&gt; (1024,)
			self.received_data = np.expand_dims(self.received_data, axis=-1)  # (1024,) --&gt; (1024,1)
			data_real = np.real(self.received_data)  # (1024,1)
			# print 'data_real:', data_real[0][0]
			data_imag = np.imag(self.received_data)  # (1024,1)
			# print 'data_imag:', data_imag[0][0]
			predicted_data = np.concatenate((data_real, data_imag), axis=1)  # (1024,2)
			predicted_data = np.expand_dims(predicted_data, axis=0)  # (1024,2) --&gt; (1, 1024,2)
			#print 'predicted_data:', predicted_data[0][0][0], predicted_data[0][0][1]

			start_time = datetime.datetime.now()
			print '***********************************************************'
			print 'Predict start:',start_time
			predict = self.model.predict(predicted_data)
			predict_list = list(np.squeeze(predict))
			predict = predict_list.index(max(predict_list))

			self.predict_cnt = self.predict_cnt + 1
			if predict == self.predict_correct_index:
				self.predict_correct_cnt = self.predict_correct_cnt + 1
			
			
			print 'Recognize as:', self.modulations[predict]
			end_time = datetime.datetime.now()			
			print 'Predict end:',end_time
			print 'Using time:',end_time - start_time
			print 'Recognize accuracy:', self.predict_accuracy, '%'
			print '***********************************************************'

			if self.predict_cnt&gt;=1000:
				self.predict_accuracy = round(100.0 * self.predict_correct_cnt/1000.0, 1)
				#self.predict_accuracy = self.predict_correct_cnt
				print 'HHH Recognize accuracy:', self.predict_accuracy, '%'
				self.predict_cnt = 0
				self.predict_correct_cnt = 0
							
			self.received_data = []
			self.received_data_length = 0		

			#data_percent = round(100.0*self.received_data_length/self.max_data_length, 1)
			#print 'count', self.data_count, 'max_length', self.max_data_length, 'data_percent', data_percent, '%', self.start_flag

			#print 'count', self.data_count, 'temp_length', temp_data_length, 'received_length', self.received_data_length, 'max_length', self.max_data_length, 'data_percent', data_percent, '%' 

	#return len(output_items[0])
	return temp_data_length


</value></param>
<param><key>model_file</key><value>'/home/lin/workarea/PycharmProjects/tensorflow-gpu/ofdm_recognition/0gnuradio/Blind_Mod_Rec_ResNet_from_windows.h5'</value></param>
<param><key>modulations_list</key><value>['BPSK_BPSK', 'BPSK_QPSK', 'BPSK_8PSK, QPSK_BPSK', 'QPSK_QPSK', 'QPSK_8PSK']</value></param>
<param><key>rec_data_length</key><value>1024</value></param>
<param><key>true_label</key><value>'BPSK_QPSK'</value></param>
<param><key>work_mode</key><value>True</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>Generate_Dataset</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr
import h5py
import os


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, modulations='BPSK_QPSK', label='snr_10db', data_frame=2000,start_flag=False):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Generate Dataset',   # will show up in GRC
            in_sig=[np.complex64],
            out_sig=[np.int8]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
	self.modulations=modulations	     
	self.label = label
	self.max_data_length =data_frame * 1024
	self.received_data_length = 0
	self.data_count = 0 
	self.start_flag = start_flag
	
    def work(self, input_items, output_items):
        """example: multiply with constant"""
	if self.start_flag:
		if self.max_data_length - self.received_data_length &gt; 0:
			self.data_count = self.data_count + 1	
			temp_array = input_items[0][:]
			temp_data_length = len(list(temp_array))
			self.received_data_length = self.received_data_length + temp_data_length
			self.filedir = '/home/lin/workarea/PycharmProjects/tensorflow-gpu/ofdm_recognition/1snr/dataset/' + self.modulations + '/' + self.label
			if not os.path.exists(self.filedir):
				os.makedirs(self.filedir)
			self.filename = self.filedir + '/' +  str(self.data_count) + '.h5'
			self.f = h5py.File(self.filename, 'w')
			self.f[self.modulations+self.label] = temp_array
			self.f.close()

			data_percent = round(100.0*self.received_data_length/self.max_data_length, 1)
			print 'count', self.data_count, 'max_length', self.max_data_length, 'data_percent', data_percent, '%', self.start_flag
		else:
			self.start_flag = False			
			self.received_data_length = 0		
			self.data_count = 0
			print 'Data acquisition completed!'


        return len(output_items[0])


</value></param>
<param><key>data_frame</key><value>4096</value></param>
<param><key>label</key><value>str(expected_snr)+'dB'</value></param>
<param><key>modulations</key><value>'QPSK_8PSK'</value></param>
<param><key>start_flag</key><value>StartGenerateDataset</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>Set_Signal_Amplitude</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, noise_amplitude=0.1, expected_snr=10, normalize_flag=False):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Set Signal Amplitude',   # will show up in GRC
            in_sig=[np.complex64],
            out_sig=[np.complex64]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.noise_amplitude = noise_amplitude
	self.expected_snr = expected_snr
	self.normalize_flag = normalize_flag

    def work(self, input_items, output_items):
        """example: multiply with constant""" 
	# print len(input_items) # 1, The input is a list of length 1
	# print type(input_items[0]) # np.array, The elements of the list are matrices of varying length, and each element of the matrix is a complex number
	output_items[0][:] = input_items[0]
	if self.normalize_flag:
		each_sample_signal_power = np.real(input_items[0] * np.conj(input_items[0]))
		signal_average_power = np.mean(each_sample_signal_power)
		noise_average_power = self.noise_amplitude * self.noise_amplitude
		expected_power_of_output_signal = noise_average_power * (10 ** (self.expected_snr/10.0))
		# print input_items[0][0], np.conj(input_items[0][0]), signal_average_power, expected_power_of_output_signal
		output_items[0][:] = input_items[0] * np.sqrt(expected_power_of_output_signal / signal_average_power)

		each_output_signal_power = np.real(output_items[0] * np.conj(output_items[0]))
		output_signal_average_power = np.mean(each_output_signal_power)
		actual_snr = round(10 * np.log10(output_signal_average_power / noise_average_power), 2)
		# print output_items[0][0], np.conj(output_items[0][0]), output_signal_average_power
		print 'Expected SNR:', self.expected_snr, 'Actual SNR:', actual_snr
		
        return len(output_items[0])
</value></param>
<param><key>expected_snr</key><value>expected_snr</value></param>
<param><key>noise_amplitude</key><value>noise_voltage</value></param>
<param><key>normalize_flag</key><value>True</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>255</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>len_tag_key</value></param>
<param><key>packet_len</key><value>packet_len</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>display</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>name</key><value>Rx Packets</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
</block>
<block>
<key>channels_dynamic_channel_model</key>
<param><key>id</key><value>channels_dynamic_channel_model_1</value></param>
<param><key>cfo_stdev</key><value>0.01</value></param>
<param><key>LOS</key><value>True</value></param>
<param><key>cfo_maxdev</key><value>1e3</value></param>
<param><key>fD</key><value>doppler_freq</value></param>
<param><key>sro_maxdev</key><value>1e3</value></param>
<param><key>N</key><value>8</value></param>
<param><key>ntaps</key><value>8</value></param>
<param><key>delays</key><value>0.0,0.1,1.3</value></param>
<param><key>mags</key><value>1,0.99,0.97</value></param>
<param><key>K</key><value>4.0</value></param>
<param><key>sro_stdev</key><value>0.01</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>noise_amp</key><value>noise_voltage</value></param>
</block>
<block>
<key>digital_ofdm_rx</key>
<param><key>id</key><value>digital_ofdm_rx_0</value></param>
<param><key>cp_len</key><value>fft_len/4</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>header_mod</key><value>"QPSK"</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
<param><key>packet_len_key</key><value>"rx_len"</value></param>
<param><key>payload_mod</key><value>"QPSK"</value></param>
<param><key>pilot_carriers</key><value>pilot_carriers</value></param>
<param><key>pilot_symbols</key><value>pilot_symbols</value></param>
<param><key>sync_word1</key><value>sync_word1</value></param>
<param><key>sync_word2</key><value>sync_word2</value></param>
</block>
<block>
<key>digital_ofdm_tx</key>
<param><key>id</key><value>digital_ofdm_tx_0</value></param>
<param><key>cp_len</key><value>fft_len/4</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>packet_len_key</key><value>len_tag_key</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
<param><key>payload_mod</key><value>"QPSK"</value></param>
<param><key>pilot_carriers</key><value>pilot_carriers</value></param>
<param><key>pilot_symbols</key><value>pilot_symbols</value></param>
<param><key>rolloff</key><value>0</value></param>
<param><key>sync_word1</key><value>sync_word1</value></param>
<param><key>sync_word2</key><value>sync_word2</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,3,2,2</value></param>
<param><key>label1</key><value>Rx Spectrum</value></param>
<param><key>name</key><value>Rx Spectrum</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,1,2,2</value></param>
<param><key>label1</key><value>Rx Spectrum</value></param>
<param><key>name</key><value>Tx Spectrum</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>1,3,2,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Rx Packets</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>1,1,2,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>Tx Signal</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>400</value></param>
<param><key>ymin</key><value>-400</value></param>
</block>
<connection><source_block_id>BlindRecognition</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Generate_Dataset</source_block_id><sink_block_id>blocks_null_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Set_Signal_Amplitude</source_block_id><sink_block_id>channels_dynamic_channel_model_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Set_Signal_Amplitude</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Set_Signal_Amplitude</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>digital_ofdm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>digital_ofdm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_dynamic_channel_model_1</source_block_id><sink_block_id>BlindRecognition</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_dynamic_channel_model_1</source_block_id><sink_block_id>Generate_Dataset</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_dynamic_channel_model_1</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_tx_0</source_block_id><sink_block_id>Set_Signal_Amplitude</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
